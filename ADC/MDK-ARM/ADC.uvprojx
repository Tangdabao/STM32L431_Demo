# Keil uVision project ADC.uvprojx, settings and files
target ADC (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L471VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: ADC
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L471xx
  c misc: --C99
  c include: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/User
    ../Src/: stm32l4xx_hal_msp.c main.c gpio.c stm32l4xx_it.c adc.c usart.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_rcc.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_flash.c stm32l4xx_hal.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_pwr.c stm32l4xx_hal_cortex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Application/MDK-ARM
    ./: startup_stm32l471xx.s
  group readme
    ../../: Readme.txt
software components: CMSIS:CORE 4.1.0
